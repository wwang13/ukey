# Keil uVision project Project1.uvproj, settings and files
target Project1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Project1
  AfterMake: fromelf.exe --bin -o ./Project1.bin ./Project1.axf
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c include: ..\;.\Core
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT6: RAM 0x68000c00 size 0x400
  memory RVCT9: RAM 0x68000400 size 0x800
  memory RVCT10: RAM 0x68000000 size 0x400
  group startup
    ./Core/: startup.s
  group source
    ./: main.c system.c extend.c
  group header
    ./Core/: ctype.h FTRX.h
  group lib
    ./Core/: FTRX.lib RockeyLibc.lib
